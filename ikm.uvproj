# Keil uVision project ikm.uvproj, settings and files
target I_K_M (MCS-51)
  device: ADuC845 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: ikm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: START_AD.A51 ikm.c f_read.c f_write.c
